# Keil uVision project MCXN9XX_IAP.uvprojx, settings and files
target MCXN9XX_IAP_2048 (6140000::V6.14::ARMCLANG)
  device: ARMCM33 ARM
  pack: ARM.CMSIS.5.8.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x20200000,0x00020000) IROM(0x00000000,0x00200000) IROM2(0x00200000,0x00200000) CPUTYPE("Cortex-M33") CLOCK(12000000) ESEL ELITTLE
  output: MCXN9XX_2048
  AfterMake: cmd.exe /C copy "!L" "..\@L.FLM"
  c flags: Optim=3 v6Lang=3 v6LangP=1
  c define: MCXN9XX FLASH_2048 CPU_MCXN947VDF_cm33_core0
  c include: .\flash;..\..\;..\..\..\..\platform\drivers\common\;..\..\drivers
  memory RVCT4: ROM 0x0 size 0x200000
  memory RVCT5: ROM 0x200000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x20200000 size 0x20000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
  group Program Functions
    ./: FlashPrg.c
  group Device Description
    ./: FlashDev.c
  group flash
    ./flash/: fsl_flash.h fsl_flash_ffr.h fsl_flexspi_nor_flash.h
    ./flash/src/: fsl_flash.c
target MCXN9XX_IAP_2048_S (6140000::V6.14::ARMCLANG)
  device: ARMCM33 ARM
  pack: ARM.CMSIS.5.8.0
  cpu: as above
  output: MCXN9XX_2048_S
  AfterMake: cmd.exe /C copy "!L" "..\@L.FLM"
  c flags: Optim=3 v6Lang=3 v6LangP=1
  c define: MCXN9XX FLASH_2048_S CPU_MCXN947VDF_cm33_core0
  c include: as above
  memory RVCT4: ROM 0x0 size 0x200000
  memory RVCT5: ROM 0x200000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x20200000 size 0x20000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target MCXN9XX_IAP_1024 (6140000::V6.14::ARMCLANG)
  device: ARMCM33 ARM
  pack: ARM.CMSIS.5.8.0
  cpu: as above
  output: MCXN9XX_1024
  AfterMake: cmd.exe /C copy "!L" "..\@L.FLM"
  c flags: Optim=3 v6Lang=3 v6LangP=1
  c define: MCXN9XX FLASH_1024 CPU_MCXN947VDF_cm33_core0
  c include: as above
  memory RVCT4: ROM 0x0 size 0x200000
  memory RVCT5: ROM 0x200000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x20200000 size 0x20000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target MCXN9XX_IAP_1024_S (6140000::V6.14::ARMCLANG)
  device: ARMCM33 ARM
  pack: ARM.CMSIS.5.8.0
  cpu: as above
  output: MCXN9XX_1024_S
  AfterMake: cmd.exe /C copy "!L" "..\@L.FLM"
  c flags: Optim=3 v6Lang=3 v6LangP=1
  c define: MCXN9XX FLASH_1024_S CPU_MCXN947VDF_cm33_core0
  c include: as above
  memory RVCT4: ROM 0x0 size 0x200000
  memory RVCT5: ROM 0x200000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x20200000 size 0x20000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
software components: CMSIS:CORE 5.5.0
